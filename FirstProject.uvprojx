# Keil uVision project FirstProject.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FirstProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COTS\Common;.\COTS\Config\Inc;.\COTS\MCAL\Port\Inc;.\COTS\MCAL\DIO\Inc;.\COTS\MCAL\IntCtrl\Inc;.\COTS\MCAL\Systick\Inc;.\COTS\APP\Blink\Inc;.\COTS\HAL\LED\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./COTS/MCAL/IntCtrl/Src/: IntCtrl.c IntCtrl_Lcfg.c
    ./COTS/MCAL/Port/Src/: Port.c Port_Lcfg.c
    ./COTS/MCAL/DIO/Src/: Dio.c
    ./COTS/MCAL/Systick/Src/: Systick.c Systick_Lcfg.c
  group APP
    ./COTS/APP/: main.c
    ./COTS/APP/Blink/Src/: Blink.c Blink_Lcfg.c
  group HAL
    ./COTS/HAL/LED/Src/: LED.c LED_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
